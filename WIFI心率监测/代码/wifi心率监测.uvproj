# Keil uVision project wifi心率监测.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: wifi心率监测 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\headfile
  group Source Group 1
    ./: STARTUP.A51 main.c
  group ADtransfer
    ./: AD.c
  group LCD1602
    ./: lcd.c
  group ESP8266
    ./: ESP8266.c
  group st7735
    ./: st7735.c
